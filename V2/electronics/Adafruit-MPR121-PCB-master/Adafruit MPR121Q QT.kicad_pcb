# Repository Scaniox/Glassphones (continued)

## KiCad design V2/electronics/main/main.kicad_pcb

Parts:
C10, C11, C20, C24, C70, C76, C600, C601, C602, C603, C604, C605, C606, C607, C608, C609, C610, C611: 1uF; C_0402_1005Metric
C12, C13, C22, C23: 22pF; C_0402_1005Metric
C21: 0.1µF; C_0402_1005Metric
C30, C50, C51, C71, C72, C74, C75, C77, C90: 10uF; C_0402_1005Metric
C40, C41, C91: 0.1uF; C_0402_1005Metric
C80, C81, C84, C85: 10nF; C_0402_1005Metric
C82, C83, C86, C87, C88, C89, C810: 1uf; C_0402_1005Metric
CHG1: ORANGE; LED_0603_1608Metric
CN20: 2908-05WB-M6; microSD_HC_Hirose_DM3D-SF
CN70: microUSB; USB_Micro-B_Molex-105017-0001
D10: RED; LED_0603_1608Metric
D50: PWR_LED
D71, D72: MBR120; D_SOD-123
D600, D601, D602, D603, D604, D605, D606, D607, D608, D609, D610, D611: SK6812; LED_SK6812_EC15_1.5x1.5mm
FB70, FB71: FERITTE; R_0805_2012Metric
J5: Conn_01x05_Female; Hirose_DF52-5S-0.8H_1x05-1MP_P0.80mm_Horizontal
J10: Conn_01x20_Female; Hirose_DF12_DF12E3.0-20DP-0.5V_2x10_P0.50mm_Vertical
J11: Conn_01x20_Male; Hirose_DF12_DF12C3.0-20DS-0.5V_2x10_P0.50mm_Vertical
J40: CAP TOUCH SLIDER
J80: Conn_01x04_Female; Hirose_DF52-5S-0.8H_1x05-1MP_P0.80mm_Horizontal
J81: Conn_01x02_Female; Hirose_DF52-5S-0.8H_1x05-1MP_P0.80mm_Horizontal
L50: 4.7μH; L_1210_3225Metric
R10: 2.2K; R_0402_1005Metric
R20, R21, R23, R24, R25, R26, R51, R70: 100K; R_0402_1005Metric
R22: 1M; R_0402_1005Metric
R40: 75K; R_0402_1005Metric
R41, R42, R73: 10K; R_0402_1005Metric
R50: 0.33; R_0402_1005Metric
R60: 470; R_0402_1005Metric
R71: 100k; R_0402_1005Metric
R72: 1K; R_0402_1005Metric
R80, R81, R84, R85: 22; R_0402_1005Metric
R82, R83, R86, R87: 100; R_0402_1005Metric
SW1: SPST_TACT-KMR2; SW_Push_1P1T_NO_CK_KMR2
TH50: 100k NTC
TP30: BM83_MFB; TestPoint_Pad_D1.0mm
TP31: BM83_LED1; TestPoint_Pad_D1.0mm
TP32: BM83_LED2; TestPoint_Pad_D1.0mm
TP33: BM83_USB_DN; TestPoint_Pad_D1.0mm
TP34: BM83_USB_DP; TestPoint_Pad_D1.0mm
TP70: 5V VBUS; TestPoint_Pad_D1.0mm
TP71: 3.3V; TestPoint_Pad_D1.0mm
TP72: 1.8V; TestPoint_Pad_D1.0mm
TP73: GND; TestPoint_Pad_D1.0mm
U1: ATSAMD21G18_QFN; TQFN-48-1EP_7x7mm_P0.5mm_EP5.1x5.1mm
U2: VS1053B; LQFP-48_7x7mm_P0.5mm
U3: BM83
U4: MPR121Q; UQFN-20_3x3mm_P0.4mm
U5: PAM2804; TSOT-23-5
U6: AP22814AW5; SOT-23-5
U8: max9725aetc+; max9725aetc&plus_
U9: MP34DT01TR-M
U70: SPX3819-3.3; SOT-23-5
U71: AP7312-1833W6-7; SOT-23-6
U72: MCP73831T-2ACI/OT; SOT-23-5
X10: 32.768; XTAL3215
X20: ABM8G-12.288MHZ-4Y-T3; CRYSTAL_3.2X2.5

Connections:
+1V8: C75.1, C810.1, J10.11, J11.11, TP72.1, U2.5 (CVDD@0), U2.7 (CVDD@1), U2.24 (CVDD@2), U2.31 (CVDD@3), U8.9 (VDD), U8.12 (~SHDN), U71.6 (VOUT1)
+3.3VA: C24.1, CN20.4 (SD_VDD), FB71.1, R21.2, R23.1, R24.1, U2.6 (IOVDD@0), U2.14 (IOVDD@1), U2.19 (IOVDD@2), U2.32 (XTEST), U71.1 (VOUT2)
+3V3: C11.1, C40.1, C72.1, C74.1, C90.1, C91.1, J5.4, J10.15, J11.15, R20.1, R41.2, R42.2, R72.1, TH50.1, TP71.1, U1.6 (VDDA), U1.17 (VDDIO), U1.36 (VDDIO), U1.44 (VDDIN), U4.20 (VDD), U6.5 (IN), U9.1 (VDD), U9.2 (LR), U70.5 (OUT), U71.4 (EN1), U71.5 (VIN)
+BATT: C77.1, D71.2 (A), J10.7, J10.8, J11.7, J11.8, J80.2, R71.1, U72.3 (VBAT)
/A0: U1.3 (PA02/EINT2/AIN0/Y0/VOUT)
/A1: U1.7 (PB08/I8/AIN2/SERCOM4.0)
/A2: U1.8 (PB09/I9/AIN3/SERCOM4.1)
/A3: J5.5, J10.16, J11.16, R51.1, TH50.2, U1.9 (PA04/EINT4/VREFB/AIN4/SERCOM0.0)
/A4: R70.1, R71.2, U1.10 (PA05/EINT5/AIN5/SERCOM0.1)
/A5: U1.47 (PB02/I2/AIN10/SERCOM5.0)
/AIL: U3.12 (AIL)
/AIR: U3.11 (AIR)
/AOHPL: J10.3, J11.3, R84.1, R86.2, U3.8 (AOHPL)
/AOHPM: U3.7 (AOHPM)
/AOHPR: J10.4, J11.4, R85.1, R87.2, U3.6 (AOHPR)
/AREF: C76.1, U1.4 (PA03/EINT3/VREFA/AIN1)
/BAT_IN: U3.23 (BAT_IN)
/BM83_UART_RX: U1.15 (PA10/I10/AIN18/SERCOM0+2.2/I2SCK), U3.29 (P8_6/UART_RXD)
/BM83_UART_TX: U1.16 (PA11/I11/AIN19/SERCOM0+2.3/I2SF0), U3.30 (P8_5/UART_TXD)
/CHRG_STAT: CHG1.2 (A), R72.2, U1.11 (PA06/EINT6/AIN6/SERCOM0.2)
/CLKOUT: U2.15 (VCO)
/D2: J10.17, J11.17, R60.1, U1.23 (PA14/I14/SERCOM2+4.2)
/D3: J10.14, J11.14, U1.14 (PA09/I2C/I9/AIN17/SERCOM0+2.1/I2SMC), U4.1 (#IRQ)
/D4: U1.13 (PA08/I2C/AIN16/SERCOM0+2.0/I2SD1), U71.3 (EN2)
/D5: CN20.2 (CS), R24.2, U1.24 (PA15/I15/SERCOM3+4.3)
/D6: R23.2, U1.29 (PA20/I4/SERCOM3+5.2/I2SSC), U2.23 (XCS)
/D7: J10.6, J11.6, U1.30 (PA21/I5/SERCOM3+5.3/I2SFS0), U5.1 (EN)
/D9: U1.12 (PA07/I7/AIN7/SERCOM0.3/I2SD0), U2.8 (DREQ)
/D10: U1.27 (PA18/I2/SERCOM1+3.2), U2.13 (XDCS/BSYNC)
/D11: J10.18, J11.18, U1.25 (PA16/I2C/I0/SERCOM1+3.0), U6.4 (EN)
/D12: U1.28 (PA19/I3/SERCOM1+3.3/I2SD0)
/D13: R10.1, U1.26 (PA17/I2C/I1/SERCOM1+3.1)
/D+: CN70.2 (D+), U1.34 (PA25/I13/SERCOM3+5.3/D+)
/D-: CN70.3 (D-), U1.33 (PA24/I12/SERCOM3+5.2/D-)
/DMIC1_CLK: U3.17 (DMIC1_CLK), U9.3 (CLK)
/DMIC1_L: U3.19 (DMIC1_L), U9.4 (DOUT)
/DMIC1_R: U3.18 (DMIC1_R)
/DN: TP33.1, U3.36 (DM)
/DP: TP34.1, U3.37 (DP)
/DR1: U3.1 (DR1)
/DT1: U3.4 (DT1)
/ELEC0: J40.1, U4.8 (ELE0)
/ELEC1: J40.2, U4.9 (ELE1)
/ELEC2: J40.3, U4.10 (ELE2)
/ELEC3: J40.4, U4.11 (ELE3)
/ELEC4: J40.5, U4.12 (ELE4/LED0)
/ELEC5: J40.6, U4.13 (ELE5/LED1)
/ELEC6: J40.7, U4.14 (ELE6/LED2)
/ELEC7: J40.8, U4.15 (ELE7/LED3)
/ELEC8: J40.9, U4.16 (ELE8/LED4)
/ELEC9: J40.10, U4.17 (ELE9/LED5)
/ELEC10: J40.11, U4.18 (ELE10/LED6)
/ELEC11: J40.12, U4.19 (ELE11/LED7)
/GPIO0: R25.2, U2.33 (GPIO0)
/GPIO1: R26.2, U2.34 (GPIO1)
/LED1: TP31.1, U3.32 (LED1)
/LED2: TP32.1, U3.34 (LED2)
/LED_FB: D50.1 (K), J5.2, R50.1, U5.5 (FB)
/LED_SW: C50.1, D50.2 (A), J5.3, L50.2
/L_OUT: J80.5, U8.8 (OUTL)
/MCLK1: U3.5 (MCLK1)
/MICBIAS: U3.15 (MICBIAS)
/MICN1: U3.13 (MICN1)
/MICN2: U3.9 (MICN2)
/MICP1: U3.14 (MICP1)
/MICP2: U3.10 (MICP2)
/MISO: CN20.7 (DATA_OUT), U1.21 (PA12/I12/I2C/SERCOM2+4.0), U2.30 (SO)
/MOSI: CN20.3 (DATA_IN), U1.19 (PB10/I10/SERCOM4.2/I2SMC), U2.29 (SI)
/P0_0: U3.49 (P0_0/UART_TX_IND)
/P0_1: U3.44 (P0_1)
/P0_2: U3.33 (P0_2)
/P0_3: U3.38 (P0_3)
/P0_5: U3.40 (P0_5)
/P0_6: U3.35 (P0_6)
/P0_7: U3.45 (P0_7)
/P1_2: U3.46 (P1_2/TDI_CPU/SDL)
/P1_3: U3.47 (P1_3/TCK_CPU/SDA)
/P1_6: U3.41 (P1_6/PWM1)
/P2_3: U3.42 (P2_3)
/P2_6: U3.21 (P2_6)
/P2_7: U3.39 (P2_7)
/P3_2: U3.20 (P3_2)
/P3_4: U3.31 (P3_4/UART_RTS)
/P3_7: U3.48 (P3_7/UART_CTS)
/PWR(MFB): TP30.1, U3.26 (PWR(MFB))
/RFS1: U3.2 (RFS1)
/RGB_VDD: C600.1, C601.1, C602.1, C603.1, C604.1, C605.1, C606.1, C607.1, C608.1, C609.1, C610.1, C611.1, D600.3 (VDD), D601.3 (VDD), D602.3 (VDD), D603.3 (VDD), D604.3 (VDD), D605.3 (VDD), D606.3 (VDD), D607.3 (VDD), D608.3 (VDD), D609.3 (VDD), D610.3 (VDD), D611.3 (VDD), U6.1 (OUT)
/R_OUT: J81.5, U8.7 (OUTR)
/SCL: J10.13, J11.13, R41.1, U1.32 (PA23/I2C/I7/SERCOM3+5.1/SOF), U4.2 (SCL)
/SCLK: CN20.5 (SCLK), U1.20 (PB11/I11/SERCOM4.3/I2SCL), U2.28 (SCLK)
/SCLK1: U3.3 (SCLK1)
/SDA: J10.12, J11.12, R42.1, U1.31 (PA22/I2C/I6/SERCOM3+5.0), U4.3 (SDA)
/SK1_AMB_DET: U3.27 (SK1_AMB_DET)
/SK2_KEY_AD: U3.28 (SK2_KEY_AD)
/SWCLK: U1.45 (PA30/I10/SECOM1.2/SWCLK)
/SWDIO: U1.46 (PA31/I11/SECOM1.3/SWDIO)
/SYS_PWR: U3.24 (SYS_PWR)
/VDD_IO: U3.25 (VDD_IO)
/vs1053_LEFT: J10.1, J11.1, R80.1, R82.2, U2.46 (LEFT)
/vs1053_RIGHT: J10.2, J11.2, R81.1, R83.2, U2.39 (RIGHT)
/~RESET: C21.1, R20.2, SW1.1, SW1.3 (P1), U1.40 (/RESET), U2.3 (XRESET), U3.43 (RST_N)
GND: C10.2, C11.2, C12.2, C13.2, C21.2, C22.2, C23.2, C24.2, C30.2, C40.2, C41.2, C50.2, C51.1, C71.2, C72.2, C74.2, C75.2, C76.2, C77.2, C90.2, C91.2, C600.2, C601.2, C602.2, C603.2, C604.2, C605.2, C606.2, C607.2, C608.2, C609.2, C610.2, C611.2, CN20.6 (GND@3), CN20.MT1 (GND@2), CN20.MT2 (GND@1), CN70.5 (GND), CN70.6 (GND), CN70.BASE@2 (GND), CN70.GND, CN70.SPRT@1 (GND), CN70.SPRT@2 (GND), CN70.SPRT@3 (GND), CN70.SPRT@4 (GND), D10.1 (C), D600.1 (VSS), D601.1 (VSS), D602.1 (VSS), D603.1 (VSS), D604.1 (VSS), D605.1 (VSS), D606.1 (VSS), D607.1 (VSS), D608.1 (VSS), D609.1 (VSS), D610.1 (VSS), D611.1 (VSS), FB70.1, J10.19, J10.20, J11.19, J11.20, J80.3, R25.1, R26.1, R40.1, R50.2, R51.2, R70.2, R73.2, SW1.2 (S), SW1.4 (S1), TP73.1, U1.5 (GNDA), U1.18 (GND), U1.35 (GND), U1.42 (GND), U1.49 (GND), U1.THERMAL (GND), U2.4 (DGND@0)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
GNDA: C20.2, C70.2, C80.2, C81.2, C84.2, C85.2, C89.2, C810.2, FB70.2, J10.5, J11.5, J80.4, J81.4, U2.37 (AGND@0), U2.40 (AGND@1), U2.41 (AGND@2), U2.47 (AGND@3), U8.6 (SGND), U8.11 (PGND), U8.13 (EP)
unnamed: C10.1, U1.43 (VDDCORE)
unnamed: C12.1, U1.1 (PA00/EINT0/SERCOM1.0), X10.P$1
unnamed: C13.1, U1.2 (PA01/EINT1/SERCOM1.1), X10.P$2
unnamed: C20.1, U2.44 (RCAP)
unnamed: C22.1, R22.1, U2.17 (XTALOUT), X20.1
unnamed: C23.1, R22.2, U2.18 (XTALIN), X20.2
unnamed: C41.1, U4.5 (VREG)
unnamed: C80.1, R80.2
unnamed: C81.1, R81.2
unnamed: C82.1, R82.1
unnamed: C82.2, C86.2, U8.3 (INL)
unnamed: C83.1, C87.2, U8.4 (INR)
unnamed: C83.2, R83.1
unnamed: C84.1, R84.2
unnamed: C85.1, R85.2
unnamed: C86.1, R86.1
unnamed: C87.1, R87.1
unnamed: C88.1, U8.1 (C1N)
unnamed: C88.2, U8.10 (C1P)
unnamed: C89.1, U8.2 (PVSS), U8.5 (VSS)
unnamed: CHG1.1 (C), U72.1 (STAT)
unnamed: CN70.1 (VBUS), D72.2 (A)
unnamed: D10.2 (A), R10.2
unnamed: D600.2 (DIN), R60.2
unnamed: D600.4 (DOUT), D601.2 (DIN)
unnamed: D601.4 (DOUT), D602.2 (DIN)
unnamed: D602.4 (DOUT), D603.2 (DIN)
unnamed: D603.4 (DOUT), D604.2 (DIN)
unnamed: D604.4 (DOUT), D605.2 (DIN)
unnamed: D605.4 (DOUT), D606.2 (DIN)
unnamed: D606.4 (DOUT), D607.2 (DIN)
unnamed: D607.4 (DOUT), D608.2 (DIN)
unnamed: D608.4 (DOUT), D609.2 (DIN)
unnamed: D609.4 (DOUT), D610.2 (DIN)
unnamed: D610.4 (DOUT), D611.2 (DIN)
unnamed: L50.1, U5.3 (SW)
unnamed: R21.1, U2.26 (RX)
unnamed: R40.2, U4.7 (REXT)
unnamed: R73.1, U72.5 (PROG)
VBUS: C30.1, C51.2, C71.1, D71.1 (C), D72.1 (C), J10.9, J10.10, J11.9, J11.10, TP70.1, U3.22 (ADAP_IN), U5.4 (VIN), U70.1 (IN), U70.3 (EN), U72.4 (VDD)
VDDA: C70.1, FB71.2, U2.38 (AVDD@0), U2.43 (AVDD@1), U2.45 (AVDD@2)

Notes on the sheet:
POWER AND FILTERING (7)
RED LED
Analog Supply Filtering
1.0K = 1000mA
Mezzanine connector
Caps: UKA0J471MPD1TD
transients during power up which can
TXLED
USB AND BATTERY CHARGING
POWER LED (5)
10K = 100mA
N/C
= 497µF
RXD
SAMD21 MCU (1)
free in FIFO
1 / (2*π*f*Xc)
'clicks' ... this setup should minimize
RGB LEDS (6)
that. See section 8 of
VS1053 oscillator requires
USBHOSTEN
Enabling the IC too soon can cause
AUDIO MUX (8)
DREQ high = at least 32 bytes
1 / (6.2832*20hz*16)
Disable SPI boot with GPIO0 low
TOUCH SLIDER (4)
SPI CS Pullups
MIC (9)
VS1053B AUDIO CODEC (2)
damage the earphones and causes
BM83 BTM (3)
1 / (6.2832*20hz*32)
1M resistor for DC bias
32 ohm load at 20Hz cuttoff
16 ohm load at 20Hz cuttoff
2.0K = 500mA
3.3v supply
vs1053 1.8v supply

Board: 4 copper layers, 65.0 x 40.0 mm, 121 parts (59 on the bottom side), 89 nets.

## KiCad design V2/electronics/components/Adafruit-VS1053-Breakout-PCB-master/Adafruit VS1053 Breakout.kicad_pcb

Parts:
C1, C2: 220uF; PANASONIC_C
C4, C5: 10pF; _0805MP
C6, C7, C19, C20: 10µF; _0805MP
C8, C26: 0.1µF; _0805MP
C21, C22: 10nF (0.01uF); _0805MP
CN1: 2908-05WB-M6; MICROSD
D1: 1N4148; SOD-323
FB1, FB2: FERITTE; _0805MP
FID1, FID2: FIDUCIAL""; FIDUCIAL_1MM
JP2, JP3: HEADER-1X16ROUND; 1X16_ROUND
R1: 1M; _0805MP
R2: 100K; _0805MP
R3, R4: 20; _0805MP
R6, R7: 100; _0805MP
R8, R9, R16: 100K; RESPACK_4X0603
R10: 10K; 0805-NO
U1: VS1053B; LQFP48
U2: AP7312-1833W6-7; SOT23-6
U3: 74HC4050D; SOIC16
U$50, U$51, U$52, U$53: MOUNTINGHOLE3.0THIN; MOUNTINGHOLE_3.0_PLATEDTHIN
Y1: ABM8G-12.288MHZ-4Y-T3; CRYSTAL_3.2X2.5

Connections:
1.8V: C6.1, U1.5 (CVDD@0), U1.7 (CVDD@1), U1.24 (CVDD@2), U1.31 (CVDD@3), U2.6 (VOUT1)
3.3V: C7.1, C19.1, CN1.4 (SD_VDD), FB1.1, JP2.8, JP3.5, R9.5 (2), R9.6 (2), R9.7 (2), R10.2, U1.6 (IOVDD@0), U1.14 (IOVDD@1), U1.19 (IOVDD@2), U1.32 (XTEST), U2.1 (VOUT2), U3.1 (VCC)
AGND: C8.2, C21.2, C22.2, FB2.2, JP2.3, JP2.4, JP3.4, U1.37 (AGND@0), U1.40 (AGND@1), U1.41 (AGND@2), U1.47 (AGND@3)
AVDD: C8.1, FB1.2, R2.1, U1.38 (AVDD@0), U1.43 (AVDD@1), U1.45 (AVDD@2)
CLKOUT: U1.15 (VCO)
CS_3V: U1.23 (XCS), U3.10 (4Y)
CS_5V: JP2.14, R9.2 (1), U3.9 (4A)
DREQ: JP2.6, U1.8 (DREQ)
GND: C4.2, C5.2, C6.2, C7.2, C19.2, C20.2, C26.2, CN1.6 (GND@3), CN1.MT1 (GND@2), CN1.MT2 (GND@1), FB2.1, JP2.5, JP2.9, R8.5 (2), R8.6 (2), R8.7 (2), R8.8 (2), R9.8 (2), R16.5 (2), R16.6 (2), R16.7 (2), R16.8 (2), U1.4 (DGND@0), U1.16 (DGND@1), U1.20 (DGND@2), U1.21 (DGND@3), U1.22 (DGND@4), U1.35 (GND), U2.2 (GND), U3.8 (GND)
GPIO0: JP3.6, R16.1, U1.33 (GPIO0)
GPIO1: JP3.7, R16.2 (1), U1.34 (GPIO1)
GPIO2: JP3.8, R16.3 (1), U1.9 (GPIO2/DCLK)
GPIO3: JP3.9, R16.4 (1), U1.10 (GPIO3/SDATA)
GPIO4: JP3.10, R8.1, U1.36 (GPIO4/I2S_LROUT)
GPIO5: JP3.11, R8.2 (1), U1.25 (GPIO5/I2S_MCLK)
GPIO6: JP3.12, R8.3 (1), U1.11 (GPIO6/I2S_SCLK)
GPIO7: JP3.13, R8.4 (1), U1.12 (GPIO7/I2S_SDATA)
LEFT: R3.1, R7.2, U1.46 (LEFT)
LEFT_FILTERED: C2.+, R7.1
LINE2: JP3.1, U1.48 (LINE2)
L_OUT: C2.-, JP2.2
MIC_N: JP3.3, U1.2 (MIC_N)
MIC_P: JP3.2, U1.1 (MIC_P/LINEIN)
MISO: CN1.7 (DATA_OUT), JP2.10, U1.30 (SO)
MOSI_3V: CN1.3 (DATA_IN), U1.29 (SI), U3.4 (2Y)
MOSI_5V: JP2.11, U3.5 (2A)
unnamed: C5.1, R1.1, U1.17 (XTALOUT), Y1.1
unnamed: C4.1, R1.2, U1.18 (XTALIN), Y1.2
unnamed: C21.1, R3.2
unnamed: C22.1, R4.2
RIGHT: R4.1, R6.2, U1.39 (RIGHT)
RIGHT_FILTERED: C1.+, R6.1
RST_3V: C26.1, R2.2, U1.3 (XRESET), U3.2 (1Y)
RST_5V: JP2.13, R9.1, U3.3 (1A)
RX: D1.A, R10.1, U1.26 (RX)
RX_5V: D1.C, JP3.15
R_OUT: C1.-, JP2.1
SCLK_3V: CN1.5 (SCLK), U1.28 (SCLK), U3.6 (3Y)
SCLK_5V: JP2.12, U3.7 (3A)
SDCS_3V: CN1.2 (CS), U3.12 (5Y)
SDCS_5V: JP2.15, R9.3 (1), U3.11 (5A)
SD_DETECT: CN1.CD1 (CARD_DETECT), JP3.16
TX: JP3.14, U1.27 (TX)
VIN: C20.1, JP2.7, U2.3 (EN2), U2.4 (EN1), U2.5 (VIN)
XDCS_3V: U1.13 (XDCS/BSYNC), U3.15 (6Y)
XDCS_5V: JP2.16, R9.4 (1), U3.14 (6A)

Notes on the sheet:
http://www.vlsi.fi/uploads/media/vs10XXan.pdf
= 497µF
Not buffered (3V3)~{}
Caps: UKA0J471MPD1TD
Enabling the IC too soon can cause
Power Supply/Decoupling
DREQ high = at least 32 bytes
Disable SPI boot with GPIO0 low
1 / (2*π*f*Xc)
C4,C5 = 10pF
C4,C5 = 2*10pF - 2*5pF
VS1053 oscillator requires
C4,C5 = 2*CL - 2*Cstray
Set RX to IOVDD if not used
'clicks' ... this setup should minimize
1 / (6.2832*20hz*32)
damage the earphones and causes
1M resistor for DC bias
transients during power up which can
1 / (6.2832*20hz*16)
Analog Supply Filtering
= 249µF
that. See section 8 of
C1, C2 =
16 ohm load at 20Hz cuttoff
32 ohm load at 20Hz cuttoff
free in FIFO

Board: 2 copper layers, 27.6 x 57.7 mm, 40 parts (1 on the bottom side), 45 nets.

Other parts of the board:
U$31: ADAFRUIT_3.5MM
U$55: ADAFRUIT_TEXT_20MM

## KiCad design V2/electronics/components/ICS 43432 I2S microphone/breakout board/ICS 43432 mic breakout/ICS 43432 mic breakout.kicad_pcb

Parts:
C1: 10uf; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J1: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical
U1: ICS-43432; ICS_43432

Connections:
unnamed: C1.1, J1.3, U1.3 (VDD)
unnamed: C1.2, J1.4, U1.4 (GND)
unnamed: J1.1, U1.1 (LR_sel)
unnamed: J1.2, U1.2 (config)
unnamed: J1.5, U1.5 (LRCLK)
unnamed: J1.6, U1.6 (BCLK)
unnamed: J1.7, U1.7 (DATA)

Board: 2 copper layers, 10.8 x 20.0 mm, 3 parts (1 on the bottom side), 7 nets.
