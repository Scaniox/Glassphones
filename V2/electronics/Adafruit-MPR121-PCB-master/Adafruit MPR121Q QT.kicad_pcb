# Repository Scaniox/Glassphones (continued)

## KiCad design V1 - esp32/electronics/glassphones - main pcb/glassphones - main pcb.kicad_pcb

Parts:
BOOT1: SW_Push; TL3365_button
Ba1: SW_Push_45deg; TL3365_button
Bb1: SW_Push_45deg; TL3365_button
Bd1: SW_Push_45deg; TL3365_button
Bl1: SW_Push_45deg; TL3365_button
Br1: SW_Push_45deg; TL3365_button
Bu1: SW_Push_45deg; TL3365_button
C1: 470nf; C_0603_1608Metric
C2: 2.2uf; C_0603_1608Metric
C3, C4, C5, C6, C7, C8, C9: 1uf; C_0603_1608Metric
D1: PWR; LED_0603_1608Metric
D2: CON; LED_0603_1608Metric
D3: Play; LED_0603_1608Metric
D4: Menu; LED_0603_1608Metric
D5: CHRG; LED_0603_1608Metric
J1: USB_B_Micro; USB_Micro-B_Molex-105017-0001
J2: DM3D-SF
J3: Raudio; TestPoint_Pad_D1.5mm
J4: GNDA; TestPoint_Pad_D1.5mm
J5: Conn_01x05_Female; Hirose_DF52-5S-0.8H_1x05-1MP_P0.80mm_Horizontal
NT1: Net-Tie_2; NetTie-2_SMD_Pad0.5mm
R1, R5, R6, R7: 10k; R_0603_1608Metric
R2: 10k X 4; EXB-38V103JV
R3: 470k; R_0603_1608Metric
R4: 180k; R_0603_1608Metric
R8, R9, R10, R11, R12: 330; R_0603_1608Metric
RST1: SW_Push; TL3365_button
U1: TinyPICO_Nano
U2: max9850eti+; max9850eti&plus_
U3: ICS-43432; ICS_43432

Connections:
+3V3: C6.1, C7.1, C8.1, C9.1, J2.4 (VDD), R5.2, R6.2, R7.2, U1.8 (3v3), U2.4 (DVDD), U2.17 (AVDD), U2.26 (PVDD), U3.1 (LR_sel), U3.3 (VDD)
BAT_sense: R3.2, R4.1, U1.36 (IO36)
BCLK: U1.17 (IO26), U2.2 (BCLK), U3.6 (BCLK)
BOOT+SD_PULLUP: BOOT1.2, R1.1, R2.5 (R4.2), R2.6 (R3.2), R2.7 (R2.2), R2.8 (R1.2), U1.29 (IO0)
Bcol1: Bl1.1, Bu1.1, R5.1, U1.35 (IO37)
Bcol2: Bb1.1, Bd1.1, R6.1, U1.34 (IO38)
Bcol3: Ba1.1, Br1.1, R7.1, U1.33 (IO39)
DAC_DATA: U1.23 (IO23), U2.3 (SDIN)
GND: BOOT1.1, C2.2, C7.2, C8.2, C9.2, J1.5 (GND), J1.6 (Shield), J2.6 (VSS), J2.9, J2.10, J2.11, J2.12, J2.13, J2.14, J5.1, J5.MP, NT1.1, R4.2, RST1.1, U1.2 (GND), U2.6 (DGND), U2.7 (ADD), U2.24 (PGND), U2.29 (EP), U3.2 (config), U3.4 (GND)
GNDA: C3.1, C4.1, C5.1, C6.2, J4.1, J5.2, NT1.2, U2.14 (AGND)
LRCLK: U1.16 (IO27), U2.1 (LRCLK), U3.5 (LRCLK)
L_Audio: J5.3, U2.19 (HPL)
Lcol1: D1.2 (A), D3.2 (A), U1.18 (IO25)
Lcol2: D2.2 (A), D4.2 (A), U1.19 (IO32)
MCLK: U1.28 (IO21), U2.5 (MCLK)
MIC_DATA: U1.27 (IO22), U3.7 (DATA)
unnamed: C1.1, U2.25 (C1P)
unnamed: C1.2, U2.23 (C1N)
unnamed: C2.1, U2.20 (SVSS), U2.22 (PVSS)
unnamed: C3.2, U2.15 (NREG)
unnamed: C4.2, U2.16 (PREG)
unnamed: C5.2, U2.13 (REF)
unnamed: D1.1 (K), R8.2
unnamed: D2.1 (K), R9.2
unnamed: D3.1 (K), R10.2
unnamed: D4.1 (K), R11.2
unnamed: D5.1 (K), R12.2
unnamed: R12.1, U1.1 (STAT)
RST: RST1.2, U1.3 (RESET), U1.7 (EN)
R_Audio: J3.1, U2.18 (HPR)
SCL: U1.24 (IO19), U2.27 (SCL)
SDA: U1.25 (IO18), U2.28 (SDA)
SD_CLK: J2.5 (CLK), U1.14 (IO14)
SD_CMD: J2.3 (CMD), R1.2, U1.15 (IO15)
SD_DAT0: J2.7 (DAT0), R2.1 (R1.1), U1.10 (IO2)
SD_DAT1: J2.8 (DAT1), R2.2 (R2.1), U1.11 (IO4)
SD_DAT2: J2.1 (DAT2), R2.3 (R3.1), U1.12 (IO12)
SD_DAT3: J2.2 (DAT3), R2.4 (R4.1), U1.13 (IO13)
V_BAT: J5.5, R3.1, U1.9 (VBAT)
row1: Bd1.2, Br1.2, Bu1.2, R8.1, R9.1, U1.26 (IO5)
row2: Ba1.2, Bb1.2, Bl1.2, R10.1, R11.1, U1.30 (IO9)
usb_5v: D5.2 (A), J1.1 (VBUS), U1.4 (5V)
usb_d+: J1.3 (D+), U1.6 (D+)
usb_d-: J1.2 (D-), U1.5 (D-)

Notes on the sheet:
25/07/2021
Glassphones main PCB
Buttons and Lights
Connectors
SD card
Maxim9850eti+ audio DAC AMP

Board: 2 copper layers, 57.5 x 21.8 mm, 43 parts (22 on the bottom side), 44 nets.

## Commit log

2021-08-21 previous idf code
2021-08-21 now builds; woohoo!
2021-08-22 semi working
    boots, inits, discovers and connects on az delivery esp32 wroom, but fails to discover on tinypico nano esp32 pico d4
2021-08-23 testing discovery using espidf example
    discovery works on az delivery esp32 WROOM, but not on tinypico nano esp32 pico d4
2021-09-01 experimented with ESP-ADF, but still didn't work
2022-03-29 LEDs 29 03 22
2022-04-04 04 04 2022
2022-04-04 i did a stupid, need to go back one sec
2022-04-04 Revert "i did a stupid, need to go back one sec"
    This reverts commit a6d8b2aea34f96029431820e36dbc3aa056df4ba.
2022-04-04 fixed it 04 04 2022
2022-04-04 main sch layout 04 04 22
2022-04-05 main sch labelling 05 04 22
2022-04-05 main sch symbols 05 04 22
2022-04-06 main sch assigning footprints 06 04 22
2022-04-07 main sch footprints 07 04 22
2022-04-07 main sch audio out tests 07 04 22
2022-04-08 BM83 line in tests - no success 08 04 22
2022-04-08 main sch footprints 08 04 22
2022-04-24 pcb design done 24 04 22
2022-05-08 hardware reference
    designs that reflect the V2 PCBs
2022-05-23 bring up - mpr121 i2c all zeros
2022-08-30 way too many things to keep track of
    theres a serial passthrough programmer that allows the mcu to act as a serial adapter to program the bm83 now
2022-09-23 pre uni sync up
2022-11-02 started main v2, layout and flow
2022-11-05 05 11 22 program layout
2022-11-05 workspace set up
2022-11-05 started main.c+.h, common.h
2022-11-06 created some headers
2022-11-23 rejiged tap struct declaration
2022-11-25 menu system header started
2023-01-22 figured out accessing of other module's methods
2023-01-26 remembering stuff i forgot i wrote
2023-01-29 more planning
2023-02-12 just make the modules globals!
2023-02-12 heck yeah, it builds
2023-02-12 debug serial Serial interface is now cnstrctor arg
2023-02-14 rearange serial_io into a switch
