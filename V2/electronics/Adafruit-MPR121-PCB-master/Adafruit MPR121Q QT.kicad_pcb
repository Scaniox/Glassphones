# Repository Scaniox/Glassphones

File README.md:

# Glassphones

A Bluetooth headset but built into glasses frames; this is V1, so is a bulky experiment

MCU is an esp32 (tinypico nano), programmed using espidf 4.3

codec is a Maxim9850eti+, which is sent audio over i2s and control signals over i2c.
on the same i2s bus (sharing BCLK and LRCLK) is an ics43432 MEMS microphone

audio drivers are tiny bone conduction speakers.

micro SD card using 4 bit SD bus used for secondary storage

## KiCad design V2/electronics/Adafruit-MPR121-PCB-master/Adafruit MPR121Q QT.kicad_pcb

Board: 2 copper layers, 33.0 x 19.2 mm, 28 parts (3 on the bottom side), 25 nets.

Parts:
C4, C7: 0.1uF; 0603-NO
C5, C6: 10uF; 0805-NO
CONN3, CONN4: STEMMA_I2C_QT; JST_SH4
D1: RED; CHIPLED_0603_NOOUTLINE
D2: GREEN; CHIPLED_0603_NOOUTLINE
FID3, FID4: FIDUCIAL_1MM
JP1: 1X13_ROUND_70
JP2: 1X07_ROUND_70
Q3: BSS138; SOT363
R1, R6, R9: 10K; 0603-NO
R5: 75K; 0603-NO
R7: 1K; 0603-NO
R8: 10K; RESPACK_4X0603
SJ1: SOLDERJUMPER_ARROW_NOPASTE
U1: MPR121; QFN20_3MM_NOTHERMAL
U2: AP2112K-3.3; SOT23-5
U$9: PCBFEAT-REV-040
U$34, U$35: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
U$37: ADAFRUIT_3.5MM
U$39, U$40: STEMMAQT

Connections:
3.3V: C6.1, C7.1, JP2.2, Q3.2, Q3.5, R1.2, R7.2, R8.2, R8.4, R9.1, SJ1.1, U1.20, U2.5
ADDR: JP2.7, R6.2, SJ1.2, U1.4
ELEC0: JP1.12, U1.8
ELEC1: JP1.11, U1.9
ELEC2: JP1.10, U1.10
ELEC3: JP1.9, U1.11
ELEC4: JP1.8, U1.12
ELEC5: JP1.7, U1.13
ELEC6: JP1.6, U1.14
ELEC7: JP1.5, U1.15
ELEC8: JP1.4, U1.16
ELEC9: JP1.3, U1.17
ELEC10: JP1.2, U1.18
ELEC11: JP1.1, U1.19
GND: C4.2, C5.2, C6.2, C7.2, CONN3.1, CONN3.MT1, CONN3.MT2, CONN4.1, CONN4.MT1, CONN4.MT2, D2.C, JP1.13, JP2.3, R5.1, R6.1, U1.6, U2.2
INT: D1.C, JP2.6, R1.1, U1.1
unnamed: D1.A, R7.1
unnamed: C4.1, U1.5
unnamed: R5.2, U1.7
unnamed: D2.A, R9.2
SCL: CONN3.4, CONN4.4, JP2.4, Q3.6, R8.8
SCL_3V: Q3.1, R8.7, U1.2
SDA: CONN3.3, CONN4.3, JP2.5, Q3.3, R8.6
SDA_3V: Q3.4, R8.5, U1.3
VCC: C5.1, CONN3.2, CONN4.2, JP2.1, R8.1, R8.3, U2.1, U2.3

## KiCad design V2/electronics/feather vs1053b tests/Adafruit-Music-Maker-FeatherWing-PCB-master/Adafruit VS1053 Headphone FeatherWing.kicad_pcb

Parts:
C1, C2: 220uF; PANASONIC_C
C3: 1uF; 0603-NO
C4, C5: 22pF; 0603-NO
C6: 10µF; _0805MP
C8, C19: 1µF; 0603-NO
C20: 10µF; 0805-NO
C21, C22: 10nF; 0603-NO
C26: 0.1µF; 0603-NO
CN1: 2908-05WB-M6; MICROSD
FB1, FB2: FERITTE; 0805-NO
FID1, FID2: FIDUCIAL""; FIDUCIAL_1MM
JP1: HEADER-1X12; 1X12_ROUND
JP2, JP4: HEADER-1X2ROUND; 1X02_ROUND
JP3: HEADER-1X13; 1X13_ROUND_70
JP5: HEADER-1X1ROUND; 1X01_ROUND
MIDI: SOLDERJUMPER; SOLDERJUMPER_ARROW_NOPASTE
MS1: FEATHERWING_NODIM
R1: 1M; 0603-NO
R2: 100K; 0603-NO
R3, R4: 22; 0603-NO
R6, R7: 100; 0603-NO
R16: 100K; RESPACK_4X0603
RST: SOLDERJUMPERCLOSED; SOLDERJUMPER_CLOSEDWIRE
SW1: KMR2; BTN_KMR2_4.6X2.8
U1: VS1053B; LQFP48
U2: AP7312-1833W6-7; SOT23-6
X1: AUDIO_3.5MMJACK_4POL; 4UCONN_18510
Y1: ABM8G-12.288MHZ-4Y-T3; CRYSTAL_3.2X2.5

Connections:
1.8V: C6.1, U1.5 (CVDD@0), U1.7 (CVDD@1), U1.24 (CVDD@2), U1.31 (CVDD@3), U2.6 (VOUT1)
3.3V: C19.1, C20.1, CN1.4 (SD_VDD), FB1.1, MIDI.1, MS1.2 (3V), R16.7 (2), R16.8 (2), U1.6 (IOVDD@0), U1.14 (IOVDD@1), U1.19 (IOVDD@2), U1.32 (XTEST), U2.1 (VOUT2), U2.3 (EN2), U2.4 (EN1), U2.5 (VIN); also elsewhere on the board
AGND: C3.2, C8.2, C21.2, C22.2, FB2.2, JP2.2, JP4.2, SW1.A, SW1.A' (P1), U1.37 (AGND@0), U1.40 (AGND@1), U1.41 (AGND@2), U1.47 (AGND@3), X1.1-GND (TIP)
AVDD: C8.1, FB1.2, R2.1, U1.38 (AVDD@0), U1.43 (AVDD@1), U1.45 (AVDD@2)
CLKOUT: U1.15 (VCO)
DREQ: JP1.8, MS1.21 (GPIO9), U1.8 (DREQ)
GND: C4.2, C5.2, C6.2, C19.2, C20.2, C26.2, CN1.6 (GND@3), CN1.MT1 (GND@2), CN1.MT2 (GND@1), FB2.1, JP3.13, MS1.4 (GND), R16.5 (2), R16.6 (2), U1.4 (DGND@0), U1.16 (DGND@1), U1.20 (DGND@2), U1.21 (DGND@3), U1.22 (DGND@4), U1.35 (GND), U2.2 (GND)
GPIO0: R16.4 (1), U1.33 (GPIO0)
GPIO1: MIDI.2, R16.3 (1), U1.34 (GPIO1); also elsewhere on the board
LEFT: R3.1, R7.2, U1.46 (LEFT)
LEFT_FILTERED: C2.+, R7.1
L_OUT: C2.-, JP4.1, X1.2-TIP (RING3)
MISO: CN1.7 (DATA_OUT), JP3.4, MS1.13 (GPIOMISO), U1.30 (SO)
MOSI: CN1.3 (DATA_IN), JP3.5, MS1.12 (GPIOMOSI), U1.29 (SI)
MP3CS: JP1.9, MS1.20 (GPIO6), R16.2 (1), U1.23 (XCS)
MP3RST: C26.1, JP5.1, R2.2, RST.1, U1.3 (XRESET); also elsewhere on the board
MP3_RX: JP3.2, MS1.15 (GPIOTX), U1.26 (RX)
unnamed: C5.1, R1.1, U1.17 (XTALOUT), Y1.1
unnamed: C4.1, R1.2, U1.18 (XTALIN), Y1.2
unnamed: C3.1, U1.44 (RCAP)
unnamed: JP1.2, MS1.27 (EN)
unnamed: C21.1, R3.2
unnamed: C22.1, R4.2
unnamed: JP1.4, MS1.25 (GPIO13)
unnamed: JP1.5, MS1.24 (GPIO12)
unnamed: JP1.6, MS1.23 (GPIO11)
unnamed: JP1.11, MS1.18 (GPIOSCL)
unnamed: JP1.12, MS1.17 (GPIOSDA)
unnamed: JP3.1, MS1.16 (NC)
unnamed: JP3.3, MS1.14 (GPIORX)
unnamed: JP3.7, MS1.10 (GPIOA5)
unnamed: JP3.8, MS1.9 (GPIOA4)
unnamed: JP3.9, MS1.8 (GPIOA3)
unnamed: JP3.10, MS1.7 (GPIOA2)
unnamed: JP3.11, MS1.6 (GPIOA1)
unnamed: JP3.12, MS1.5 (GPIOA0)
RIGHT: R4.1, R6.2, U1.39 (RIGHT)
RIGHT_FILTERED: C1.+, R6.1
R_OUT: C1.-, JP2.1, X1.3-OUTER_SLEEVE (RING2)
SCLK: CN1.5 (SCLK), JP3.6, MS1.11 (GPIOSCK), U1.28 (SCLK)
SD_CS: CN1.2 (CS), JP1.10, MS1.19 (GPIO5), R16.1
TX: U1.27 (TX)
USB: JP1.3, MS1.26 (USB)
VBAT: JP1.1, MS1.28 (VBAT)
XDCS: JP1.7, MS1.22 (GPIO10), U1.13 (XDCS/BSYNC)
~RESET: MS1.1 (~RESET), RST.2, SW1.B (S), SW1.B' (S1); also elsewhere on the board

Notes on the sheet:
http://www.vlsi.fi/uploads/media/vs10XXan.pdf
C1, C2 =
'clicks' ... this setup should minimize
free in FIFO
1M resistor for DC bias
that. See section 8 of
damage the earphones and causes
1 / (2*π*f*Xc)
C4,C5 = 10pF
1 / (6.2832*20hz*16)
transients during power up which can
16 ohm load at 20Hz cuttoff
32 ohm load at 20Hz cuttoff
Caps: UKA0J471MPD1TD
Disable SPI boot with GPIO0 low
Power Supply/Decoupling
C4,C5 = 2*CL - 2*Cstray
1 / (6.2832*20hz*32)
= 249µF
= 497µF
C4,C5 = 2*10pF - 2*5pF
Enabling the IC too soon can cause
VS1053 oscillator requires
DREQ high = at least 32 bytes
Analog Supply Filtering

Board: 2 copper layers, 50.8 x 22.9 mm, 41 parts (5 on the bottom side), 44 nets.

Other parts of the board:
MIDI0: SOLDERJUMPER_ARROW_NOPASTE
RST0: SOLDERJUMPER_CLOSEDWIRE
U$36: ADAFRUIT_3.5MM
U$37: FEATHERLOGO_SMALL
U$43: PCBFEAT-REV-040
U$55: ADAFRUIT_TEXT_20MM

Their connections:
3.3V: MIDI0.1; also elsewhere on the board
GPIO1: MIDI0.2; also elsewhere on the board
MP3RST: RST0.1; also elsewhere on the board
~RESET: RST0.2; also elsewhere on the board

## KiCad design V2/electronics/BM83 prog/BM83 prog/BM83 prog.kicad_pcb

Board: 2 copper layers, 37.3 x 14.6 mm, 14 parts (0 on the bottom side), 9 nets.

Parts:
D1: LED1; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: LED2; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: Conn_01x09_Male; PinHeader_1x09_P2.54mm_Vertical
J2: USB_B_Micro; USB_Micro-B_Molex-105017-0001
MFB: PWR MFB; SW_Push_1P1T_NO_CK_KMR2
TP30: BM83_MFB; 0.65mm pogo pin
TP31: BM83_LED1; 0.65mm pogo pin
TP32: BM83_LED2; 0.65mm pogo pin
TP33: BM83_USB_DN; 0.65mm pogo pin
TP34: BM83_USB_DP; 0.65mm pogo pin
TP70: 5V VBUS; 0.65mm pogo pin
TP71: 3.3V; 0.65mm pogo pin
TP72: 1.8V; 0.65mm pogo pin
TP73: GND; 0.65mm pogo pin

Connections:
+1V8: J1.3, TP72.1
+3V3: D1.2 (A), D2.2 (A), J1.2, MFB.2, TP71.1
/DN: J1.8, J2.2 (D-), TP33.1
/DP: J1.9, J2.3 (D+), TP34.1
/LED1: D1.1 (K), J1.6, TP31.1
/LED2: D2.1 (K), J1.7, TP32.1
/PWR(MFB): J1.5, MFB.1, TP30.1
GND: J1.4, J2.5 (GND), J2.6 (Shield), TP73.1
VBUS: J1.1, J2.1 (VBUS), TP70.1

## KiCad design V2/electronics/Adafruit-Feather-M0-Basic-Proto-PCB-master/Adafruit Feather M0 Basic rev C.kicad_pcb

Parts:
C1, C7, C14: 1uF; 0603-NO
C2, C4: 22pF; 0603-NO
C3, C6, C8: 10µF; 0805-NO
C5: 10uF; 0805-NO
CHG0: ORANGE; CHIPLED_0805_NOOUTLINE
D1: MBR120; SOD-123
JP1: HEADER-1X16ROUND; 1X16_ROUND
JP3: HEADER-1X12; 1X12_ROUND
L0: RED; CHIPLED_0805_NOOUTLINE
R1, R3: 100k; 0603-NO
R2: 1K; 0603-NO
R6: 100K; 0603-NO
R7: 2.2K; 0603-NO
R8: 10K\; 0603-NO
SW1: SPST_TACT-KMR2; KMR2
TP1, TP2: TESTPOINTROUND1.5MM; TESTPOINT_ROUND_1.5MM
U2: SPX3819-3.3; SOT23-5
U3: MCP73831T-2ACI/OT; SOT23-5
U$4: ATSAMD21G18_QFN; TQFN48_7MM
U$31, U$32: MOUNTINGHOLE2.5; MOUNTINGHOLE_2.5_PLATED
U$34, U$35: FIDUCIAL""; FIDUCIAL_1MM
X1: JSTPH; JSTPH2
X2: 32.768; XTAL3215
X3: microUSB; 4UCONN_20329_V2

Connections:
+3V3: C5.1, C7.1, C8.1, JP1.15, U2.5 (OUT), U$4.6 (VDDA), U$4.17 (VDDIO), U$4.36 (VDDIO), U$4.44 (VDDIN)
A0: JP1.12, U$4.3 (PA02/EINT2/AIN0/Y0/VOUT)
A1: JP1.11, U$4.7 (PB08/I8/AIN2/SERCOM4.0)
A2: JP1.10, U$4.8 (PB09/I9/AIN3/SERCOM4.1)
A3: JP1.9, U$4.9 (PA04/EINT4/VREFB/AIN4/SERCOM0.0)
A4: JP1.8, U$4.10 (PA05/EINT5/AIN5/SERCOM0.1)
A5: JP1.7, U$4.47 (PB02/I2/AIN10/SERCOM5.0)
AREF: C14.1, JP1.14, U$4.4 (PA03/EINT3/VREFA/AIN1)
D0: JP1.3, U$4.16 (PA11/I11/AIN19/SERCOM0+2.3/I2SF0)
D1: JP1.2, U$4.15 (PA10/I10/AIN18/SERCOM0+2.2/I2SCK)
D2: U$4.23 (PA14/I14/SERCOM2+4.2)
D3: U$4.14 (PA09/I2C/I9/AIN17/SERCOM0+2.1/I2SMC)
D4: U$4.13 (PA08/I2C/AIN16/SERCOM0+2.0/I2SD1)
D5: JP3.10, U$4.24 (PA15/I15/SERCOM3+4.3)
D6: JP3.9, U$4.29 (PA20/I4/SERCOM3+5.2/I2SSC)
D7: U$4.30 (PA21/I5/SERCOM3+5.3/I2SFS0)
D8: U$4.11 (PA06/EINT6/AIN6/SERCOM0.2)
D9: JP3.8, R3.2, R6.1, U$4.12 (PA07/I7/AIN7/SERCOM0.3/I2SD0)
D10: JP3.7, U$4.27 (PA18/I2/SERCOM1+3.2)
D11: JP3.6, U$4.25 (PA16/I2C/I0/SERCOM1+3.0)
D12: JP3.5, U$4.28 (PA19/I3/SERCOM1+3.3/I2SD0)
D13: JP3.4, R7.1, U$4.26 (PA17/I2C/I1/SERCOM1+3.1)
D+: U$4.34 (PA25/I13/SERCOM3+5.3/D+), X3.D+
D-: U$4.33 (PA24/I12/SERCOM3+5.2/D-), X3.D-
EN: JP3.2, R1.2, U2.3 (EN)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C14.2, JP1.1, JP1.13, L0.C, R6.2, R8.2, SW1.2 (S), SW1.4 (S1), U2.2 (GND), U3.2 (VSS), U$4.5 (GNDA), U$4.18 (GND), U$4.35 (GND), U$4.42 (GND), U$4.THERMAL (GND), X1.1, X3.BASE@1 (GND), X3.BASE@2 (GND), X3.GND, X3.SPRT@1 (GND), X3.SPRT@2 (GND), X3.SPRT@3 (GND), X3.SPRT@4 (GND)
MISO: JP1.4, U$4.21 (PA12/I12/I2C/SERCOM2+4.0)
MOSI: JP1.5, U$4.19 (PB10/I10/SERCOM4.2/I2SMC)
unnamed: CHG0.C, R2.1
unnamed: L0.A, R7.2
unnamed: R2.2, U3.1 (STAT)
unnamed: R8.1, U3.5 (PROG)
unnamed: C2.1, U$4.1 (PA00/EINT0/SERCOM1.0), X2.P$1
unnamed: C4.1, U$4.2 (PA01/EINT1/SERCOM1.1), X2.P$2
SCK: JP1.6, U$4.20 (PB11/I11/SERCOM4.3/I2SCL)
SCL: JP3.11, U$4.32 (PA23/I2C/I7/SERCOM3+5.1/SOF)
SDA: JP3.12, U$4.31 (PA22/I2C/I6/SERCOM3+5.0)
SWCLK: TP1.P$1, U$4.45 (PA30/I10/SECOM1.2/SWCLK)
SWDIO: TP2.P$1, U$4.46 (PA31/I11/SECOM1.3/SWDIO)
VBAT: C3.1, D1.A, JP3.1, R3.1, U3.3 (VBAT), X1.2
VBUS: C6.1, CHG0.A, D1.C, JP3.3, R1.1, U2.1 (IN), U3.4 (VDD), X3.VBUS
VDDCORE: C1.1, U$4.43 (VDDCORE)
~RESET: JP1.16, SW1.1, SW1.3 (P1), U$4.40 (/RESET)

Notes on the sheet:
N/C
TXD
2.0K = 500mA
1.0K = 1000mA
RESET
BREAKOUTS
TXLED
RXLED
USB AND BATTERY CHARGING
RXD
USBHOSTEN
10K = 100mA
POWER AND FILTERING
5.0K = 200mA
RED LED

Board: 2 copper layers, 50.8 x 22.9 mm, 39 parts (5 on the bottom side), 38 nets.

Other parts of the board:
@HOLE0, @HOLE1: (no value)
U$7, U$12: ADAFRUIT_3.5MM
U$9: FEATHERLOGO
U$13: PCBFEAT-REV-040

Notices in the files:
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
